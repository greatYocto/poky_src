IMAGE_INSTALL += "nano"
