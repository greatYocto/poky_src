inherit externalsrc

EXTERNALSRC = "${COREBASE}/../source/mykernel/kernel-source"

