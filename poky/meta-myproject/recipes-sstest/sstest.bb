DESCRIPTION = "This file is for signature test"
LICENSE = "CLOSED"

do_compile () {
    bbwarn "Hello!, this is signature test"
}
